# Disable buggy coreutils' uptime command
ALTERNATIVE_PRIORITY[uptime] = "0"
