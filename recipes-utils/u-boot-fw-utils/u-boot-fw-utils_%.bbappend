SRCREV = "${AUTOREV}"

PV = "v2017.03-at91+git${SRCPV}"

UBRANCH = "u-boot-2017.03-emerson"
SRC_URI = "git://github.com/zaigor2/u-boot-at91.git;protocol=git;branch=${UBRANCH}"
