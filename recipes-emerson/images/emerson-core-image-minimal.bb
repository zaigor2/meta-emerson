DESCRIPTION = "A core image for Emerson sam9260 based boards"
LICENSE = "MIT"
PR = "r1"

require emerson-core-image-minimal.inc
